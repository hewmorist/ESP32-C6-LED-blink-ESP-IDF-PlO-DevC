## sdkconfig.defaults
```kconfig
#Use esptool.py --chip esp32c6 flash_id to check the flash size of the board and change this file accordingly
CONFIG_ESPTOOLPY_FLASHSIZE_8MB=y
```
